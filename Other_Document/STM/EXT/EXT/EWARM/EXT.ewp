# IAR project EXT.ewp, settings and files
configuration EXT (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; C:/Users/Duy Luan/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/STM32F4xx_HAL_Driver/Inc; C:/Users/Duy Luan/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; C:/Users/Duy Luan/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/CMSIS/Include; C:/Users/Duy Luan/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: EXT.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/STM32F4xx_HAL_Driver
    ./: 
    C:/Users/Duy Luan/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c
  group Drivers/CMSIS
    ./: 
    C:/Users/Duy Luan/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application
    ./: 
  group Application/EWARM
    ./: 
    C:/Users/Duy Luan/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/User
    ./: 
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
