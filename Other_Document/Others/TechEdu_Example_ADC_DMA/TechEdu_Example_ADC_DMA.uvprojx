# Keil uVision project TechEdu_Example_ADC_DMA.uvprojx, settings and files
target TechEdu_Example_ADC_DMA (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TechEdu_Example_ADC_DMA +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Include;.\RTE;.\RTE\Device\STM32F103VE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./Source/: Main.c Getline.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/Device/StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
    RTE/Device/STM32F103VE/: RTE_Device.h startup_stm32f10x_hd.s stm32f10x_conf.h system_stm32f10x.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
