# IAR project HID Interface.ewp, settings and files
configuration HID Interface (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: HID Interface.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Middlewares
    ./: 
  group Middlewares/USB_Device_Library
    ./: 
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Drivers
    ./: 
  group Drivers/STM32F4xx_HAL_Driver
    ./: 
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pcd.c
  group Drivers/CMSIS
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application
    ./: 
  group Application/EWARM
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/User
    ./: 
    ../Src/: main.c usbd_conf.c usbd_desc.c usb_device.c stm32f4xx_hal_msp.c usbd_custom_hid_if.c stm32f4xx_it.c
